# Copyright (c) 2018 Arm Limited and Contributors. All rights reserved.
#
# SPDX-License-Identifier: MIT

# No GPLv3 allowed in this image
IMAGE_LICENSE_CHECKER_BLACKLIST = ""
inherit image-license-checker
