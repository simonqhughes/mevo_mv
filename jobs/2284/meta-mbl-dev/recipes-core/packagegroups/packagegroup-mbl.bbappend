# Copyright (c) 2018 Arm Limited and Contributors. All rights reserved.
#
# SPDX-License-Identifier: MIT



PACKAGEGROUP_MBL_PKGS_remove = "ca-certificates"
PACKAGEGROUP_MBL_PKGS_remove = "docker"
PACKAGEGROUP_MBL_PKGS_remove = " opkg"
PACKAGEGROUP_MBL_PKGS_remove = " mbl-app-manager"
PACKAGEGROUP_MBL_PKGS_remove = " mbl-app-lifecycle-manager"
PACKAGEGROUP_MBL_PKGS_remove = " mbl-app-update-manager"
PACKAGEGROUP_MBL_PKGS_remove = " mbl-firmware-update-manager"

PACKAGEGROUP_MBL_PKGS_remove = " python3-debugger"
PACKAGEGROUP_MBL_PKGS_remove = " python3-doctest"
PACKAGEGROUP_MBL_PKGS_remove = " python3-logging"

PACKAGEGROUP_MBL_PKGS_remove = " python3-ntpath"
PACKAGEGROUP_MBL_PKGS_remove = " python3-pip"
PACKAGEGROUP_MBL_PKGS_remove = " python3-runpy"
PACKAGEGROUP_MBL_PKGS_remove = " python3-shell"
PACKAGEGROUP_MBL_PKGS_remove = " python3-venv"
PACKAGEGROUP_MBL_PKGS_remove = " mbl-cloud-client"
PACKAGEGROUP_MBL_PKGS_remove = " connman"
PACKAGEGROUP_MBL_PKGS_remove = " connman-client"

