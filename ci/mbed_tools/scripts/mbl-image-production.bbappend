# Copyright (c) 2018 Arm Limited and Contributors. All rights reserved.
#
# SPDX-License-Identifier: MIT


IMAGE_INSTALL_remove = "packagegroup-mbl-production"
